# Keil uVision project MK24FN256.uvprojx, settings and files
target Normal (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK24FN256VDC12 NXP
  pack: NXP.MK24F25612_DFP.10.0.1
  cpu: IRAM(0x1fff0000,0x010000) IRAM2(0x20000000,0x030000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MK24FN256
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SDK_OS_FREE_RTOS, CPU_MK24FN256VDC12, FSL_RTOS_FREE_RTOS, NDEBUG
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186,66,111,223  --library_interface=armcc
  c include: ..\app;..\bsp;..\components\CMSIS\Include;..\components\MK24F25612;..\components\MK24F25612\drivers;..\components\MK24F25612\utilities;..\fml;..\mdl;..\mdl\os\include;..\mdl\os\portable\MemMang;..\mdl\os\portable\RVDS\ARM_CM4F;..\mdl\rttviewer;..\task;..\uti;..\mdl\ModbusRTU
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ..\components\MK24F25612\arm\MK24FN256xxx12_flash.scf
  group app
    ../app/: clock_config.c main.c FreeRTOSConfig.h
  group bsp
    ../bsp/: bsp_flash.c bsp_conf.h bsp_init.c bsp_uart.c bsp_tim.c bsp_clock.c
  group components
    ../components/MK24F25612/: system_MK24F25612.c
    ../components/MK24F25612/arm/: startup_MK24F25612.s
  group components/dirver
    ../components/MK24F25612/drivers/: fsl_adc16.c fsl_clock.c fsl_cmp.c fsl_cmt.c fsl_common.c fsl_crc.c fsl_dac.c fsl_dmamux.c fsl_dspi.c fsl_dspi_edma.c fsl_dspi_freertos.c fsl_edma.c fsl_ewm.c fsl_flash.c fsl_ftm.c fsl_gpio.c fsl_i2c.c fsl_i2c_edma.c fsl_i2c_freertos.c fsl_llwu.c fsl_lptmr.c fsl_pdb.c fsl_pit.c fsl_pmc.c fsl_rcm.c fsl_rnga.c fsl_rtc.c fsl_sai.c fsl_sai_edma.c fsl_sim.c fsl_smc.c fsl_uart.c fsl_uart_edma.c fsl_uart_freertos.c fsl_vref.c fsl_wdog.c
  group fml
    ../fml/: system_param.c
  group mdl
    ../mdl/os/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../mdl/os/portable/RVDS/ARM_CM4F/: fsl_tickless_systick.c port.c
    ../mdl/os/portable/MemMang/: heap_4.c
    ../mdl/rttviewer/: clog.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../mdl/: rtos_tools.c
  group mdl/modbus
    ../mdl/ModbusRTU/: ModbusCRC.c ModbusHardwareInit.c ModbusRTU_Slave.c
  group task
    ../task/: first_task.c second_task.c task_list.c modbus_task.c
  group uti
    ../uti/: crc.c sort.c version.c
